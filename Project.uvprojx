# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM3, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING
  c include: .\Library;.\Start;.\User;.\System;.\Hardware;.\Led;.\Test;.\FFT;.\Dsp_FFT;.\UGUI
  asm define: ARM_MATH_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_wwdg.h stm32f10x_usart.h stm32f10x_tim.h stm32f10x_spi.h stm32f10x_sdio.h stm32f10x_rtc.h stm32f10x_rcc.h stm32f10x_pwr.h stm32f10x_iwdg.h stm32f10x_i2c.h stm32f10x_gpio.h stm32f10x_fsmc.h stm32f10x_flash.h stm32f10x_exti.h stm32f10x_dma.h stm32f10x_dbgmcu.h stm32f10x_dac.h stm32f10x_crc.h stm32f10x_cec.h stm32f10x_can.h stm32f10x_bkp.h stm32f10x_adc.h misc.h
  group System
    ./System/: delay.c delay.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Hardware
    ./Hardware/: bitmap.h bitmap.c ws2812b.c ws2812b.h ws2812b_conf.h mike.c mike.h mike_conf.h OLED.c OLED.h OLED_Font.h OLED_conf.h ssd1306.c ssd1306.h ssd1306_conf.h ssd1306_Font.h
  group Led
    ./Led/: led.h led.c time.c time.h
  group Test
    ./Test/: test.h led_example.c ssd1306_example.c ugui_example.c
  group FFT
    ./FFT/: fft.c fft.h fft_show.c
  group Dsp_FFT
    ./Dsp_FFT/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s stm32_dsp.h table_fft.h cr4_fft_64_stm32.s
  group UGUI
    ./UGUI/: ugui.c ugui.h ugui_config.h
